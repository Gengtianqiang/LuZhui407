# Keil uVision project HAL.uvprojx, settings and files
target HAL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HAL +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../BSP;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../HARDWARE/Encoder;../HARDWARE/Motor_GPIO;../APP/balance_task;../APP/bg_task;../APP/imu_task;../APP/uart_task;../BSP/battery;../BSP/buzzer;../BSP/Encoder;../BSP/icm20948/app;../BSP/icm20948/lib;../BSP/led;../BSP/motor;../BSP/Motor_GPIO;../BSP/sleep;../BSP/timer;../BSP/util;../BSP/VOFA+;../BSP/icm20948/lib/include;../BSP/jdy28m_geng;../BSP/jdy28m;../BSP/4G_DTU;../BSP/NRF24L01
  asm include: ../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/User/Core
    ../Core/Src/: System_Init.c main.c freertos.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group APP/balance_task
    ../APP/balance_task/: balance.c twr_control.c control.c filter.c PID.c balance_core.c pdoa_control.c
  group APP/uart_task
    ../APP/uart_task/: uart_task.c uart_callback.c
  group APP/imu_task
    ../APP/imu_task/: imu_task.c
  group APP/bg_task
    ../APP/bg_task/: bg_task.c
  group BSP/battery
    ../BSP/battery/: battery.c
  group BSP/buzzer
    ../BSP/buzzer/: buzzer.c
  group BSP/encoder
    ../BSP/Encoder/: Encoder.c
  group BSP/jdy28m_geng
    ../BSP/jdy28m_geng/: jdy_driver.c mesh_mode.c
  group BSP/jdy28m
    ../BSP/jdy28m/: forward.c jdy28m.c Parser.c response.c transmit.c
  group BSP/led
    ../BSP/led/: led.c
  group BSP/motor
    ../BSP/motor/: motor.c
  group BSP/sleep
    ../BSP/sleep/: sleep.c
  group BSP/util
    ../BSP/util/: RingByteBuffer.c
  group BSP/vofa
    ../BSP/VOFA+/: Vofa.c Vofa_if.c Vofa+.c
  group BSP/timer
    ../BSP/timer/: tim.c
  group BSP/moter_gpio
    ../BSP/Motor_GPIO/: Motor_GPIO.c
  group BSP/icm20948/lib
    ../BSP/icm20948/lib/: icm20948.c ICM_20948_CONTROL.c
  group BSP/icm20948/app
    ../BSP/icm20948/app/: icm20948_app.c imu_output.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_uart.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group BSP/DTU_4G
    ../BSP/4G_DTU/: bsp_4g.c
  group BSP/NRF24L01
    ../BSP/NRF24L01/: NRF24L01.c NRF24L01_APP.c
